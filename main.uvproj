# Keil uVision project main.uvproj, settings and files
target main (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sources
    ./: main.c enav.c eth_socket.c eth_w5500.c eth_wizchip_conf.c lcd_core.c i2c.c rtc.c touch.c usart.c misc.c dma.c startup_stm32f10x_md.s stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c
  group includes
    ./: dma.h encoder.h fps_counter.h usart.h main.h misc.h stm32f10x.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h system_stm32f10x.h i2c.h lcd_commands.h lcd_core.h lcd_glcdfont.h pins.txt stm32f10x_i2c.h hw_config.h touch.h enav.h stm32f10x_exti.h eth_socket.h eth_w5500.h eth_wizchip_conf.h stm32f10x_bkp.h stm32f4xx_rtc.h stm32f10x_pwr.h stm32f10x_rtc.h
